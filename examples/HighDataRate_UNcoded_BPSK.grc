options:
  parameters:
    generate_options: qt_gui
    id: Encoded_ASM_DUALchain
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: access_code
  id: variable
  parameters:
    value: '''''.join([str(i) for i in (syncword+1)//2])'
  states: {}
- name: freq
  id: variable
  parameters:
    value: '80000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '15000000'
  states: {}
- name: syncword
  id: variable
  parameters:
    value: 2*np.unpackbits(np.frombuffer(bytes.fromhex(syncword_hex), dtype = 'uint8')).astype('int')-1
  states: {}
- name: syncword_hex
  id: variable
  parameters:
    value: '''1ACFFC1D'''
  states: {}
- name: HighDataRate_Modem_Chunk_ExtractBPSK_0
  id: HighDataRate_Modem_Chunk_ExtractBPSK
  parameters: {}
  states: {}
- name: HighDataRate_Modem_Chunk_ExtractBPSK_0_0
  id: HighDataRate_Modem_Chunk_ExtractBPSK
  parameters: {}
  states: {}
- name: HighDataRate_Modem_Chunk_ExtractBPSK_0_1
  id: HighDataRate_Modem_Chunk_ExtractBPSK
  parameters: {}
  states: {}
- name: HighDataRate_Modem_Extract_Frame_0
  id: HighDataRate_Modem_Extract_Frame
  parameters: {}
  states: {}
- name: HighDataRate_Modem_Resolve_Phase_0
  id: HighDataRate_Modem_Resolve_Phase
  parameters: {}
  states: {}
- name: HighDataRate_Modem_TAG_CHUNKpreamble_0
  id: HighDataRate_Modem_TAG_CHUNKpreamble
  parameters: {}
  states: {}
- name: HighDataRate_Modem_TAG_CHUNKpreamble_0_0
  id: HighDataRate_Modem_TAG_CHUNKpreamble
  parameters: {}
  states: {}
- name: HighDataRate_Modem_TAG_CHUNKpreamble_0_1
  id: HighDataRate_Modem_TAG_CHUNKpreamble
  parameters: {}
  states: {}
- name: HighDataRate_Modem_Tag_FrameASM_0
  id: HighDataRate_Modem_Tag_FrameASM
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_0_0_0
  id: blocks_complex_to_real
  parameters:
    affinity: '7'
  states: {}
- name: blocks_complex_to_real_0_0_0_0_0
  id: blocks_complex_to_real
  parameters:
    affinity: '7'
  states: {}
- name: blocks_complex_to_real_0_0_0_0_0_0
  id: blocks_complex_to_real
  parameters:
    affinity: '7'
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    affinity: '3'
    file: /home/davem/gr-HighDataRate_Modem/examples/FINAL_RS_FRAMES_ONLY
    type: byte
  states: {}
- name: blocks_file_source_0_0_0
  id: blocks_file_source
  parameters:
    affinity: '1'
    file: /home/davem/gr-HighDataRate_Modem/examples/BBFileModBPSK_UNCODED_ONLY_withASM
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_file_source_0_0_0_0
  id: blocks_file_source
  parameters:
    affinity: '2'
    file: /home/davem/gr-HighDataRate_Modem/examples/PreAmbleFileSOURCE_for_BPSK_READY_Complex
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_keep_m_in_n_0
  id: blocks_keep_m_in_n
  parameters:
    affinity: '2'
    m: '82000'
    minoutbuf: 82000*2
    n: '210000'
    offset: '0'
    type: complex
  states: {}
- name: blocks_keep_m_in_n_0_0
  id: blocks_keep_m_in_n
  parameters:
    affinity: '2'
    m: '82000'
    minoutbuf: 82000*2
    n: '210000'
    offset: '0'
    type: complex
  states: {}
- name: blocks_keep_m_in_n_0_0_0
  id: blocks_keep_m_in_n
  parameters:
    affinity: '2'
    m: '82000'
    minoutbuf: 82000*2
    n: '210000'
    offset: '0'
    type: complex
  states: {}
- name: blocks_keep_m_in_n_0_1
  id: blocks_keep_m_in_n
  parameters:
    affinity: '3'
    m: '39240'
    n: '41510'
    offset: '2270'
    type: byte
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    affinity: '2'
    minoutbuf: 140000*2
    num_items: '70000'
    type: complex
  states: {}
- name: blocks_skiphead_0_0
  id: blocks_skiphead
  parameters:
    affinity: '2'
    minoutbuf: 140000*2
    num_items: '140000'
    type: complex
  states: {}
- name: blocks_stream_mux_0
  id: blocks_stream_mux
  parameters:
    affinity: '2'
    lengths: (3048, 82000)
    minoutbuf: '85048'
    type: complex
  states: {}
- name: blocks_stream_mux_0_0
  id: blocks_stream_mux
  parameters:
    affinity: '2'
    lengths: (3048, 82000)
    minoutbuf: '85048'
    type: complex
  states: {}
- name: blocks_stream_mux_0_1
  id: blocks_stream_mux
  parameters:
    affinity: '2'
    lengths: (3048, 82000)
    minoutbuf: '85048'
    type: complex
  states: {}
- name: blocks_stream_mux_2
  id: blocks_stream_mux
  parameters:
    affinity: '7'
    lengths: (41510, 41510,41510)
    num_inputs: '3'
    type: byte
  states: {}
- name: digital_binary_slicer_fb_0_0
  id: digital_binary_slicer_fb
  parameters:
    affinity: '7'
  states: {}
- name: digital_binary_slicer_fb_0_0_0
  id: digital_binary_slicer_fb
  parameters:
    affinity: '7'
  states: {}
- name: digital_binary_slicer_fb_0_0_0_0
  id: digital_binary_slicer_fb
  parameters:
    affinity: '7'
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    affinity: '4'
    order: '2'
    w: 3.14159/40
  states: {}
- name: digital_costas_loop_cc_0_0
  id: digital_costas_loop_cc
  parameters:
    affinity: '5'
    order: '2'
    w: 3.14159/40
  states: {}
- name: digital_costas_loop_cc_0_0_0
  id: digital_costas_loop_cc
  parameters:
    affinity: '6'
    order: '2'
    w: 3.14159/40
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    affinity: '4'
    damping: '1.0'
    loop_bw: 6.28/100
    max_dev: '1.5'
    nfilters: '128'
    osps: '1'
    pfb_mf_taps: firdes.root_raised_cosine(32,64,1.0,1.0,704)
    resamp_type: digital.IR_PFB_NO_MF
    sps: '2.00000'
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: digital_symbol_sync_xx_0_0
  id: digital_symbol_sync_xx
  parameters:
    affinity: '5'
    damping: '1.0'
    loop_bw: 6.28/100
    max_dev: '1.5'
    nfilters: '128'
    osps: '1'
    pfb_mf_taps: firdes.root_raised_cosine(32,64,1.0,1.0,704)
    resamp_type: digital.IR_PFB_NO_MF
    sps: '2.00000'
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: digital_symbol_sync_xx_0_0_0
  id: digital_symbol_sync_xx
  parameters:
    affinity: '6'
    damping: '1.0'
    loop_bw: 6.28/100
    max_dev: '1.5'
    nfilters: '128'
    osps: '1'
    pfb_mf_taps: firdes.root_raised_cosine(32,64,1.0,1.0,704)
    resamp_type: digital.IR_PFB_NO_MF
    sps: '2.00000'
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import pi
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: limesdr_sink_0
  id: limesdr_sink
  parameters:
    affinity: '1'
    allow_tcxo_dac: '0'
    analog_bandw_ch0: '0'
    calibr_bandw_ch0: '0'
    calibr_bandw_ch1: 5e6
    channel_mode: '0'
    dacVal: '125'
    digital_bandw_ch0: '0'
    digital_bandw_ch1: '0'
    gain_dB_ch0: '30'
    gain_dB_ch1: '30'
    oversample: '0'
    pa_path_ch1: '1'
    rf_freq: freq
    samp_rate: samp_rate
  states: {}
- name: limesdr_source_0
  id: limesdr_source
  parameters:
    affinity: '1'
    allow_tcxo_dac: '0'
    analog_bandw_ch0: '20000000'
    analog_bandw_ch1: 5e6
    calibr_bandw_ch0: '15000000'
    calibr_bandw_ch1: 5e6
    channel_mode: '0'
    dacVal: '125'
    digital_bandw_ch0: '15000000'
    digital_bandw_ch1: '0'
    gain_dB_ch0: '40'
    gain_dB_ch1: '30'
    minoutbuf: 140000*2
    oversample: '0'
    rf_freq: freq
    samp_rate: samp_rate
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    affinity: '7'
    size: '256'
    type: complex
    update_time: '1.5'
  states: {}

connections:
- [HighDataRate_Modem_Chunk_ExtractBPSK_0, '0', blocks_stream_mux_2, '0']
- [HighDataRate_Modem_Chunk_ExtractBPSK_0_0, '0', blocks_stream_mux_2, '1']
- [HighDataRate_Modem_Chunk_ExtractBPSK_0_1, '0', blocks_stream_mux_2, '2']
- [HighDataRate_Modem_Extract_Frame_0, '0', HighDataRate_Modem_Resolve_Phase_0, '0']
- [HighDataRate_Modem_Resolve_Phase_0, '0', blocks_file_sink_0_0, '0']
- [HighDataRate_Modem_TAG_CHUNKpreamble_0, '0', HighDataRate_Modem_Chunk_ExtractBPSK_0, '0']
- [HighDataRate_Modem_TAG_CHUNKpreamble_0_0, '0', HighDataRate_Modem_Chunk_ExtractBPSK_0_0, '0']
- [HighDataRate_Modem_TAG_CHUNKpreamble_0_1, '0', HighDataRate_Modem_Chunk_ExtractBPSK_0_1, '0']
- [HighDataRate_Modem_Tag_FrameASM_0, '0', HighDataRate_Modem_Extract_Frame_0, '0']
- [blocks_complex_to_real_0_0_0_0, '0', digital_binary_slicer_fb_0_0, '0']
- [blocks_complex_to_real_0_0_0_0_0, '0', digital_binary_slicer_fb_0_0_0, '0']
- [blocks_complex_to_real_0_0_0_0_0_0, '0', digital_binary_slicer_fb_0_0_0_0, '0']
- [blocks_file_source_0_0_0, '0', limesdr_sink_0, '0']
- [blocks_file_source_0_0_0_0, '0', blocks_stream_mux_0, '0']
- [blocks_file_source_0_0_0_0, '0', blocks_stream_mux_0_0, '0']
- [blocks_file_source_0_0_0_0, '0', blocks_stream_mux_0_1, '0']
- [blocks_keep_m_in_n_0, '0', blocks_stream_mux_0_0, '1']
- [blocks_keep_m_in_n_0_0, '0', blocks_stream_mux_0, '1']
- [blocks_keep_m_in_n_0_0_0, '0', blocks_stream_mux_0_1, '1']
- [blocks_keep_m_in_n_0_1, '0', HighDataRate_Modem_Tag_FrameASM_0, '0']
- [blocks_skiphead_0, '0', blocks_keep_m_in_n_0_0, '0']
- [blocks_skiphead_0_0, '0', blocks_keep_m_in_n_0_0_0, '0']
- [blocks_stream_mux_0, '0', digital_symbol_sync_xx_0_0, '0']
- [blocks_stream_mux_0_0, '0', digital_symbol_sync_xx_0, '0']
- [blocks_stream_mux_0_1, '0', digital_symbol_sync_xx_0_0_0, '0']
- [blocks_stream_mux_2, '0', blocks_keep_m_in_n_0_1, '0']
- [digital_binary_slicer_fb_0_0, '0', HighDataRate_Modem_TAG_CHUNKpreamble_0, '0']
- [digital_binary_slicer_fb_0_0_0, '0', HighDataRate_Modem_TAG_CHUNKpreamble_0_0, '0']
- [digital_binary_slicer_fb_0_0_0_0, '0', HighDataRate_Modem_TAG_CHUNKpreamble_0_1, '0']
- [digital_costas_loop_cc_0, '0', blocks_complex_to_real_0_0_0_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_costas_loop_cc_0_0, '0', blocks_complex_to_real_0_0_0_0_0, '0']
- [digital_costas_loop_cc_0_0_0, '0', blocks_complex_to_real_0_0_0_0_0_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [digital_symbol_sync_xx_0_0, '0', digital_costas_loop_cc_0_0, '0']
- [digital_symbol_sync_xx_0_0_0, '0', digital_costas_loop_cc_0_0_0, '0']
- [limesdr_source_0, '0', blocks_keep_m_in_n_0, '0']
- [limesdr_source_0, '0', blocks_skiphead_0, '0']
- [limesdr_source_0, '0', blocks_skiphead_0_0, '0']

metadata:
  file_format: 1
