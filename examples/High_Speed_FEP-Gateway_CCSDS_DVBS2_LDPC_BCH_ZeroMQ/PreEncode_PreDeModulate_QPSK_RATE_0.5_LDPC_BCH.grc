options:
  parameters:
    description: DVB-S2 Physical Layer (PL) Synchronization
    generate_options: qt_gui
    id: dvbs2_pl_sync
    output_language: python
    title: DVB-S2 PL Sync
  states: {}

blocks:
- name: Es
  id: variable
  parameters:
    value: '1'
  states: {}
- name: EsN0
  id: variable
  parameters:
    value: 10 ** (snr / 10)
  states: {}
- name: N0
  id: variable
  parameters:
    value: Es / EsN0
  states: {}
- name: code_rate
  id: variable
  parameters:
    value: modcod.upper().replace("8PSK", "").replace("QPSK", "")
  states: {}
- name: constellation
  id: variable
  parameters:
    value: modcod.replace(code_rate, "")
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    label: Frequency Offset (Hz)
    start: '-sym_rate/4'
    step: 1e3
    stop: sym_rate/4
    value: '10000'
  states: {}
- name: n_rrc_taps
  id: variable
  parameters:
    value: int(2*rrc_delay*sps) + 1
  states: {}
- name: pilot_len
  id: variable
  parameters:
    value: int((360-1)/16)*36
  states: {}
- name: plframe_len
  id: variable
  parameters:
    value: '33282'
  states: {}
- name: plheader_len
  id: variable
  parameters:
    value: '90'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: sps*sym_rate
  states: {}
- name: snr
  id: variable_qtgui_range
  parameters:
    label: SNR (dB)
    start: '0'
    step: '0.1'
    stop: '20'
    value: '10'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '2'
  states: {}
- name: sym_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: PreModulated_PreEncoded_PreDemodulated
  id: blocks_file_sink
  parameters:
    file: /home/davem/gr-HighDataRate_Modem/examples/High_Speed_FEP-Gateway_CCSDS_DVBS2_LDPC_BCH_ZeroMQ/DVB_QPSK_test1
    type: complex
  states: {}
- name: agc_gain
  id: parameter
  parameters:
    label: AGC gain
    type: eng_float
    value: '1'
  states: {}
- name: agc_rate
  id: parameter
  parameters:
    label: AGC update rate
    type: eng_float
    value: '1e-5'
  states: {}
- name: agc_ref
  id: parameter
  parameters:
    label: AGC's reference value
    type: eng_float
    value: '1'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: agc_gain
    max_gain: '65536'
    rate: agc_rate
    reference: agc_ref
    type: complex
  states: {}
- name: analog_noise_source_x_0_0
  id: analog_noise_source_x
  parameters:
    amp: sqrt(N0)/0.75/3
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/davem/gr-HighDataRate_Modem/examples/High_Speed_FEP-Gateway_CCSDS_DVBS2_LDPC_BCH_ZeroMQ/Sink_Full_TX_RCV_DVB_QPSK_test1
    type: byte
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/davem/gr-HighDataRate_Modem/examples/High_Speed_FEP-Gateway_CCSDS_DVBS2_LDPC_BCH_ZeroMQ/Just_CCSDS_Frame_counter
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_pack_k_bits_bb_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: blocks_rotator_cc_0_0_0
  id: blocks_rotator_cc
  parameters:
    comment: Simulate frequency offset
    phase_inc: '-2 * pi * (freq_offset / samp_rate)/2'
  states: {state: disabled}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: debug
  id: parameter
  parameters:
    label: Debug Level
    short_id: d
    type: intx
    value: '0'
  states: {}
- name: digital_costas_loop_cc_0_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: 2*3.14159/1000
  states: {}
- name: digital_symbol_sync_xx_1
  id: digital_symbol_sync_xx
  parameters:
    damping: sym_sync_damping
    loop_bw: sym_sync_loop_bw
    max_dev: '1.5'
    nfilters: rrc_nfilts
    osps: '1'
    pfb_mf_taps: firdes.root_raised_cosine(rrc_nfilts, samp_rate*rrc_nfilts, sym_rate, rolloff, n_rrc_taps*rrc_nfilts)
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: dtv_dvb_bch_bb_0
  id: dtv_dvb_bch_bb
  parameters:
    framesize2: FECFRAME_NORMAL
    rate3: C1_2
    standard: STANDARD_DVBS2
  states: {}
- name: dtv_dvb_ldpc_bb_0
  id: dtv_dvb_ldpc_bb
  parameters:
    constellation: MOD_OTHER
    framesize2: FECFRAME_NORMAL
    rate3: C1_2
    standard: STANDARD_DVBS2
  states: {}
- name: dtv_dvbs2_modulator_bc_0
  id: dtv_dvbs2_modulator_bc
  parameters:
    constellation: MOD_QPSK
    framesize: FECFRAME_NORMAL
    interpolation: INTERPOLATION_OFF
    rate1: C1_2
  states: {}
- name: dtv_dvbs2_physical_cc_0
  id: dtv_dvbs2_physical_cc
  parameters:
    constellation: MOD_QPSK
    framesize: FECFRAME_NORMAL
    goldcode: '0'
    pilots: PILOTS_OFF
    rate1: C1_2
  states: {}
- name: dvbs2rx_bch_decoder_bb_0
  id: dvbs2rx_bch_decoder_bb
  parameters:
    framesize: frame_size
    outputmode: OM_MESSAGE
    rate: code_rate
    standard: DVB-S2
  states: {}
- name: dvbs2rx_ldpc_decoder_cb_0
  id: dvbs2rx_ldpc_decoder_cb
  parameters:
    constellation: constellation
    framesize: frame_size
    infomode: INFO_OFF
    max_trials: '25'
    outputmode: OM_MESSAGE
    rate: code_rate
    standard: DVB-S2
  states: {}
- name: dvbs2rx_plsync_cc_0
  id: dvbs2rx_plsync_cc
  parameters:
    acm_vcm: 'True'
    debug_level: debug
    freq_est_period: '10'
    gold_code: '0'
    multistream: 'True'
    pls_filter_hi: '0xFFFFFFFFFFFFFFFF'
    pls_filter_lo: '0xFFFFFFFFFFFFFFFF'
    sps: sps
  states: {}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: firdes.root_raised_cosine(1.0, samp_rate, sym_rate, rolloff, n_rrc_taps)
    type: ccc
  states: {}
- name: frame_size
  id: parameter
  parameters:
    label: FECFRAME size
    short_id: f
    type: str
    value: normal
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import pi, sqrt
  states: {}
- name: in_file
  id: parameter
  parameters:
    label: path to input file containing an MPEG TS stream
    type: str
    value: ../data/example.ts
  states: {}
- name: modcod
  id: parameter
  parameters:
    label: MODCOD
    short_id: m
    type: str
    value: QPSK1/2
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 1,1
    name: '"PL Sync Output"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 1,0
    name: '"Symbol Sync Output"'
    size: '1024'
    type: complex
    update_time: '1.0'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: 0,1
    label1: I
    label2: Q
    name: '"PL Sync Output"'
    size: plframe_len - pilot_len - plheader_len
    srate: sym_rate
    type: complex
  states: {}
- name: rolloff
  id: parameter
  parameters:
    label: rolloff factor
    short_id: r
    type: eng_float
    value: '0.2'
  states: {}
- name: rrc_delay
  id: parameter
  parameters:
    label: RRC filter delay in symbol periods
    type: intx
    value: '25'
  states: {}
- name: rrc_nfilts
  id: parameter
  parameters:
    label: number of branches on the polyphase RRC filter
    type: intx
    value: '128'
  states: {}
- name: sym_sync_damping
  id: parameter
  parameters:
    label: symbol synchronizer's damping factor
    type: eng_float
    value: '1.0'
  states: {}
- name: sym_sync_loop_bw
  id: parameter
  parameters:
    label: symbol synchronizer's loop bandwidth
    type: eng_float
    value: '0.0045'
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: channel_in
  states: {}
- name: virtual_sink_1_0_0
  id: virtual_sink
  parameters:
    stream_id: channel_out
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: channel_in
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: channel_out
  states: {}

connections:
- [analog_agc_xx_0, '0', digital_symbol_sync_xx_1, '0']
- [analog_noise_source_x_0_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', virtual_sink_1_0_0, '0']
- [blocks_file_source_0_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_file_sink_0, '0']
- [blocks_pack_k_bits_bb_0_0, '0', dtv_dvbs2_modulator_bc_0, '0']
- [blocks_rotator_cc_0_0_0, '0', blocks_add_xx_0, '0']
- [blocks_throttle_0_0, '0', virtual_sink_1_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', dtv_dvb_bch_bb_0, '0']
- [digital_costas_loop_cc_0_0, '0', dvbs2rx_plsync_cc_0, '0']
- [digital_symbol_sync_xx_1, '0', digital_costas_loop_cc_0_0, '0']
- [dtv_dvb_bch_bb_0, '0', dtv_dvb_ldpc_bb_0, '0']
- [dtv_dvb_ldpc_bb_0, '0', blocks_pack_k_bits_bb_0_0, '0']
- [dtv_dvbs2_modulator_bc_0, '0', dtv_dvbs2_physical_cc_0, '0']
- [dtv_dvbs2_physical_cc_0, '0', fft_filter_xxx_0, '0']
- [dtv_dvbs2_physical_cc_0, '0', qtgui_const_sink_x_0_0, '0']
- [dvbs2rx_bch_decoder_bb_0, '0', blocks_pack_k_bits_bb_0, '0']
- [dvbs2rx_ldpc_decoder_cb_0, '0', dvbs2rx_bch_decoder_bb_0, '0']
- [dvbs2rx_plsync_cc_0, '0', PreModulated_PreEncoded_PreDemodulated, '0']
- [dvbs2rx_plsync_cc_0, '0', dvbs2rx_ldpc_decoder_cb_0, '0']
- [dvbs2rx_plsync_cc_0, '0', qtgui_const_sink_x_0, '0']
- [dvbs2rx_plsync_cc_0, '0', qtgui_time_sink_x_1, '0']
- [fft_filter_xxx_0, '0', blocks_throttle_0_0, '0']
- [virtual_source_0, '0', blocks_add_xx_0, '0']
- [virtual_source_0, '0', blocks_rotator_cc_0_0_0, '0']
- [virtual_source_0_0, '0', analog_agc_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.0
