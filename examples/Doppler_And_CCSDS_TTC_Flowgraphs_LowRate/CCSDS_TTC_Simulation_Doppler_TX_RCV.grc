options:
  parameters:
    generate_options: qt_gui
    id: Pluto_TX
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: constel
  id: variable_constellation
  parameters:
    const_points: digital.psk_2()[0]
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    soft_dec_lut: '''auto'''
    sym_map: digital.psk_2()[1]
    type: calcdist
  states: {}
- name: freq_update
  id: variable_function_probe
  parameters:
    block_id: doppler_bin
    function_name: level
    poll_rate: '32'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1024000'
  states: {}
- name: variable_cc_decoder_def_0
  id: variable_cc_decoder_def
  parameters:
    framebits: '2048'
    k: '7'
    mode: fec.CC_STREAMING
    ndim: '0'
    padding: 'False'
    polys: '[79,-109]'
    rate: '2'
    state_end: '-1'
    state_start: '0'
  states: {}
- name: variable_cc_encoder_def_0
  id: variable_cc_encoder_def
  parameters:
    framebits: '2048'
    k: '7'
    mode: fec.CC_STREAMING
    ndim: '0'
    padding: 'False'
    polys: '[79,-109]'
    rate: '2'
    state_start: '0'
  states: {}
- name: Doppler_Rotate_Correction_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-1*freq_update'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate/4
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: Doppler_Start_blocks_keep_m_in_n_0
  id: blocks_keep_m_in_n
  parameters:
    m: '1024'
    n: '32000'
    offset: '0'
    type: complex
  states: {}
- name: HighDataRate_Modem_Decode_RS_0
  id: HighDataRate_Modem_Decode_RS
  parameters:
    dual_basis: '1'
    interleave: '1'
  states: {}
- name: HighDataRate_Modem_Encode_RS_0
  id: HighDataRate_Modem_Encode_RS
  parameters:
    dual_basis: '1'
    interleave: '1'
  states: {}
- name: HighDataRate_Modem_Frame_Extract_0
  id: HighDataRate_Modem_Frame_Extract
  parameters:
    buffer_length: '30000'
    frame_length: '2072'
  states: {}
- name: HighDataRate_Modem_Resolve_Phase_0
  id: HighDataRate_Modem_Resolve_Phase
  parameters:
    buffer_length: '60000'
    frame_length: '2072'
  states: {}
- name: HighDataRate_Modem_Tag_FrameASM_1
  id: HighDataRate_Modem_Tag_FrameASM
  parameters: {}
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '250'
    type: float
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: 1/1.5/5/10
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_phase_modulator_fc_0
  id: analog_phase_modulator_fc
  parameters:
    sensitivity: '1.0'
  states: {}
- name: analog_pll_carriertracking_cc_0
  id: analog_pll_carriertracking_cc
  parameters:
    max_freq: 5000*2*3.14159/256000
    min_freq: '-5000*2*3.14159/256000'
    w: 200*2*3.14159/256000
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-64000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate/4
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_2
  id: analog_sig_source_x
  parameters:
    amp: '50000'
    freq: '0.002'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-128000'
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_argmax_xx_0
  id: blocks_argmax_xx
  parameters:
    num_inputs: '1'
    type: float
    vlen: '1024'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: '1024'
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/davem/gr-HighDataRate_Modem/examples/Doppler_And_CCSDS_TTC_Flowgraphs_LowRate/CCSDS_TTC_SINK
    type: byte
  states: {}
- name: blocks_file_source_0_0_0_0_0
  id: blocks_file_source
  parameters:
    affinity: '1'
    file: /home/davem/gr-HighDataRate_Modem/examples/Doppler_And_CCSDS_TTC_Flowgraphs_LowRate/32bitASM_CCSDS_only
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_file_source_0_0_0_0_0_0
  id: blocks_file_source
  parameters:
    affinity: '1'
    file: /home/davem/gr-HighDataRate_Modem/examples/Doppler_And_CCSDS_TTC_Flowgraphs_LowRate/Just_CCSDS_Frame_counter
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: '4'
    type: complex
  states: {}
- name: blocks_keep_one_in_n_0_0
  id: blocks_keep_one_in_n
  parameters:
    n: '4'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1.0'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1.0'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: short
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_pack_k_bits_bb_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: '4'
    type: complex
  states: {}
- name: blocks_rotator_cc_0_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: 128000*2*3.14159/1024000/2
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_stream_demux_0
  id: blocks_stream_demux
  parameters:
    lengths: (32,2040)
    type: byte
  states: {}
- name: blocks_stream_mux_0
  id: blocks_stream_mux
  parameters:
    lengths: (32, 2040)
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '223'
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0_0_1
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '2040'
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0_0_3
  id: blocks_stream_to_tagged_stream
  parameters:
    affinity: '2'
    len_tag_key: '"packet_len"'
    packet_len: '2040'
    type: byte
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '1024'
    type: complex
  states: {}
- name: blocks_stream_to_vector_2_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '223'
    type: byte
  states: {}
- name: blocks_stream_to_vector_2_0_0
  id: blocks_stream_to_vector
  parameters:
    affinity: '3'
    num_items: '255'
    type: byte
  states: {}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: byte
  states: {}
- name: blocks_tag_gate_1
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: byte
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_unpack_k_bits_bb_0_0_0_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_vco_c_0
  id: blocks_vco_c
  parameters:
    amplitude: '1'
    samp_rate: samp_rate
    sensitivity: '6.28'
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '223'
    type: byte
  states: {}
- name: blocks_vector_to_stream_0_1
  id: blocks_vector_to_stream
  parameters:
    num_items: '255'
    type: byte
  states: {}
- name: digital_additive_scrambler_bb_0
  id: digital_additive_scrambler_bb
  parameters:
    bits_per_byte: '1'
    count: '0'
    len: '7'
    mask: '0xA9'
    reset_tag_key: '"packet_len"'
    seed: '0xFF'
  states: {}
- name: digital_additive_scrambler_bb_0_0_3
  id: digital_additive_scrambler_bb
  parameters:
    affinity: '2'
    bits_per_byte: '1'
    count: '0'
    len: '7'
    mask: '0xA9'
    reset_tag_key: '"packet_len"'
    seed: '0xFF'
  states: {}
- name: digital_constellation_modulator_0_0
  id: digital_constellation_modulator
  parameters:
    constellation: constel
    differential: 'False'
    excess_bw: '0.5'
    samples_per_symbol: '16'
  states: {}
- name: digital_costas_loop_cc_0_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: 2*3.14159/1000
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: '32'
    init_phase: '0'
    loop_bw: 3.14159/100.0
    max_dev: '1.5'
    osps: '1'
    sps: '16'
    taps: firdes.root_raised_cosine(32,512,1.0,0.5,704)
    type: ccf
  states: {}
- name: doppler_bin
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: fec_extended_decoder_0
  id: fec_extended_decoder
  parameters:
    decoder_list: variable_cc_decoder_def_0
    puncpat: '''11'''
    threadtype: capillary
  states: {}
- name: fec_extended_encoder_0
  id: fec_extended_encoder
  parameters:
    encoder_list: variable_cc_encoder_def_0
    puncpat: '''11'''
    threadtype: capillary
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '1024'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(1024)
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    num_taps: '65'
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 1,0
    legend: 'False'
    name: BPSK constellation
    size: '1024'
    type: complex
    update_time: '0.50'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate/4
    fc: '0'
    fftsize: '1024'
    name: Before PM Demod
    type: complex
    ymax: '-10'
    ymin: '-60'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/4
    fc: '0'
    fftsize: '1024'
    name: '"TX"'
    type: complex
    update_time: '0.5'
    ymax: '-10'
    ymin: '-60'
  states: {}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate/4
    fc: '0'
    fftsize: '1024'
    name: Before Doppler Correction
    type: complex
    ymax: '-10'
    ymin: '-60'
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
    update_time: '1.0'
  states: {}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 0,2
    legend: 'False'
    name: Unfiltered data waveform
    size: '1000'
    srate: samp_rate
    type: complex
    update_time: '0.50'
    ymax: '2'
    ymin: '-2'
  states: {}

connections:
- [Doppler_Rotate_Correction_x_0_0, '0', blocks_multiply_xx_0_0_0, '1']
- [Doppler_Start_blocks_keep_m_in_n_0, '0', blocks_stream_to_vector_0, '0']
- [HighDataRate_Modem_Decode_RS_0, '0', blocks_vector_to_stream_0, '0']
- [HighDataRate_Modem_Encode_RS_0, '0', blocks_vector_to_stream_0_1, '0']
- [HighDataRate_Modem_Frame_Extract_0, '0', HighDataRate_Modem_Resolve_Phase_0, '0']
- [HighDataRate_Modem_Resolve_Phase_0, '0', blocks_stream_demux_0, '0']
- [HighDataRate_Modem_Tag_FrameASM_1, '0', HighDataRate_Modem_Frame_Extract_0, '0']
- [analog_const_source_x_0, '0', blocks_multiply_xx_1, '1']
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_phase_modulator_fc_0, '0', blocks_multiply_xx_0, '0']
- [analog_pll_carriertracking_cc_0, '0', blocks_complex_to_float_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0_0, '1']
- [analog_sig_source_x_0_2, '0', blocks_vco_c_0, '0']
- [blocks_add_const_vxx_0, '0', doppler_bin, '0']
- [blocks_add_xx_0, '0', blocks_keep_one_in_n_0, '0']
- [blocks_add_xx_0, '0', blocks_throttle_0_0, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_argmax_xx_0, '0', blocks_short_to_float_0, '0']
- [blocks_argmax_xx_0, '1', blocks_null_sink_0_0, '0']
- [blocks_complex_to_float_0, '0', blocks_null_sink_0, '0']
- [blocks_complex_to_float_0, '1', hilbert_fc_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_argmax_xx_0, '0']
- [blocks_complex_to_real_0, '0', fec_extended_decoder_0, '0']
- [blocks_complex_to_real_0_0_0, '0', analog_phase_modulator_fc_0, '0']
- [blocks_file_source_0_0_0_0_0, '0', blocks_stream_mux_0, '0']
- [blocks_file_source_0_0_0_0_0_0, '0', blocks_stream_to_tagged_stream_0_0_0, '0']
- [blocks_keep_one_in_n_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_keep_one_in_n_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', Doppler_Start_blocks_keep_m_in_n_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_multiply_xx_0_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_freq_sink_x_0_1, '0']
- [blocks_multiply_const_vxx_0_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [blocks_multiply_xx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_xx_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_multiply_xx_0_0, '0', qtgui_time_sink_x_1_0, '0']
- [blocks_multiply_xx_0_0_0, '0', analog_pll_carriertracking_cc_0, '0']
- [blocks_multiply_xx_0_0_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_xx_1, '0', blocks_add_const_vxx_0, '0']
- [blocks_pack_k_bits_bb_0, '0', digital_constellation_modulator_0_0, '0']
- [blocks_pack_k_bits_bb_0_0, '0', blocks_stream_to_vector_2_0_0, '0']
- [blocks_repeat_0, '0', blocks_rotator_cc_0_0, '0']
- [blocks_rotator_cc_0_0, '0', blocks_complex_to_real_0_0_0, '0']
- [blocks_short_to_float_0, '0', blocks_multiply_xx_1, '0']
- [blocks_short_to_float_0, '0', qtgui_number_sink_0, '0']
- [blocks_stream_demux_0, '0', blocks_null_sink_1, '0']
- [blocks_stream_demux_0, '1', blocks_stream_to_tagged_stream_0_0_3, '0']
- [blocks_stream_mux_0, '0', fec_extended_encoder_0, '0']
- [blocks_stream_to_tagged_stream_0_0_0, '0', blocks_stream_to_vector_2_0, '0']
- [blocks_stream_to_tagged_stream_0_0_1, '0', digital_additive_scrambler_bb_0, '0']
- [blocks_stream_to_tagged_stream_0_0_3, '0', digital_additive_scrambler_bb_0_0_3, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_2_0, '0', HighDataRate_Modem_Encode_RS_0, '0']
- [blocks_stream_to_vector_2_0_0, '0', HighDataRate_Modem_Decode_RS_0, '0']
- [blocks_tag_gate_0, '0', HighDataRate_Modem_Tag_FrameASM_1, '0']
- [blocks_tag_gate_1, '0', blocks_stream_to_tagged_stream_0_0_1, '0']
- [blocks_throttle_0_0, '0', blocks_keep_one_in_n_0_0, '0']
- [blocks_unpack_k_bits_bb_0_0_0_0_0, '0', blocks_tag_gate_1, '0']
- [blocks_vco_c_0, '0', blocks_multiply_xx_0, '1']
- [blocks_vector_to_stream_0, '0', blocks_file_sink_0, '0']
- [blocks_vector_to_stream_0_1, '0', blocks_unpack_k_bits_bb_0_0_0_0_0, '0']
- [digital_additive_scrambler_bb_0, '0', blocks_stream_mux_0, '1']
- [digital_additive_scrambler_bb_0_0_3, '0', blocks_pack_k_bits_bb_0_0, '0']
- [digital_constellation_modulator_0_0, '0', blocks_repeat_0, '0']
- [digital_costas_loop_cc_0_0, '0', blocks_complex_to_real_0, '0']
- [digital_costas_loop_cc_0_0, '0', qtgui_const_sink_x_0_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_costas_loop_cc_0_0, '0']
- [fec_extended_decoder_0, '0', blocks_tag_gate_0, '0']
- [fec_extended_encoder_0, '0', blocks_pack_k_bits_bb_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [hilbert_fc_0, '0', blocks_multiply_xx_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.0
