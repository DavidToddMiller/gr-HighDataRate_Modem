options:
  parameters:
    generate_options: qt_gui
    id: RS_CC_FEP_Gateway
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '24000000'
  states: {}
- name: variable_cc_decoder_def_0
  id: variable_cc_decoder_def
  parameters:
    framebits: '2048'
    k: '7'
    mode: fec.CC_STREAMING
    ndim: '0'
    padding: 'False'
    polys: '[79,-109]'
    rate: '2'
    state_end: '-1'
    state_start: '0'
  states: {}
- name: HighDataRate_Modem_Frame_Extract_0
  id: HighDataRate_Modem_Frame_Extract
  parameters:
    affinity: '2'
    buffer_length: '15000'
    frame_length: '2072'
  states: {}
- name: HighDataRate_Modem_Resolve_Phase_0
  id: HighDataRate_Modem_Resolve_Phase
  parameters:
    affinity: '2'
    buffer_length: '60000'
    frame_length: '2072'
  states: {}
- name: HighDataRate_Modem_Tag_FrameASM_0
  id: HighDataRate_Modem_Tag_FrameASM
  parameters:
    affinity: '2'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    affinity: '1'
    const: '-1'
    type: float
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0
  id: blocks_char_to_float
  parameters:
    affinity: '0'
    scale: '1'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    affinity: '0'
    file: /home/davem/gr-HighDataRate_Modem/examples/High_Speed_FEP-Gateway_CCSDS_Reed-Solomon_CC_ZeroMQ/CCSDS_HighSpeed_RS_SINK
    type: byte
  states: {}
- name: blocks_file_source_0_0_0_0_0_0
  id: blocks_file_source
  parameters:
    affinity: '0'
    file: /home/davem/gr-HighDataRate_Modem/examples/High_Speed_FEP-Gateway_CCSDS_Reed-Solomon_CC_ZeroMQ/Pre_RS_CC_encoded
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    affinity: '1'
    const: '2'
    type: float
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    affinity: '1'
    type: byte
  states: {}
- name: blocks_pack_k_bits_bb_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    affinity: '2'
    k: '8'
  states: {}
- name: blocks_stream_demux_0
  id: blocks_stream_demux
  parameters:
    affinity: '2'
    lengths: (255,255,255,255)
    num_outputs: '4'
    type: byte
  states: {}
- name: blocks_stream_demux_0_0
  id: blocks_stream_demux
  parameters:
    affinity: '2'
    lengths: (32,2040)
    type: byte
  states: {}
- name: blocks_stream_mux_0
  id: blocks_stream_mux
  parameters:
    affinity: '0'
    lengths: (223, 223, 223, 223)
    num_inputs: '4'
    type: byte
  states: {}
- name: blocks_stream_to_vector_2_0_0_0
  id: blocks_stream_to_vector
  parameters:
    affinity: '4'
    num_items: '255'
    type: byte
  states: {}
- name: blocks_stream_to_vector_2_0_0_1
  id: blocks_stream_to_vector
  parameters:
    affinity: '5'
    num_items: '255'
    type: byte
  states: {}
- name: blocks_stream_to_vector_2_0_0_2
  id: blocks_stream_to_vector
  parameters:
    affinity: '6'
    num_items: '255'
    type: byte
  states: {}
- name: blocks_stream_to_vector_2_0_0_2_0
  id: blocks_stream_to_vector
  parameters:
    affinity: '7'
    num_items: '255'
    type: byte
  states: {}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: byte
  states: {}
- name: blocks_throttle_0_0_0
  id: blocks_throttle
  parameters:
    affinity: '0'
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_0_0_0_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    affinity: '0'
    k: '8'
  states: {}
- name: blocks_vector_to_stream_0_1_0_0
  id: blocks_vector_to_stream
  parameters:
    affinity: '4'
    num_items: '223'
    type: byte
  states: {}
- name: blocks_vector_to_stream_0_1_0_1
  id: blocks_vector_to_stream
  parameters:
    affinity: '5'
    num_items: '223'
    type: byte
  states: {}
- name: blocks_vector_to_stream_0_1_0_2
  id: blocks_vector_to_stream
  parameters:
    affinity: '6'
    num_items: '223'
    type: byte
  states: {}
- name: blocks_vector_to_stream_0_1_0_2_0
  id: blocks_vector_to_stream
  parameters:
    affinity: '7'
    num_items: '223'
    type: byte
  states: {}
- name: ccsds_rs_decode_rs_test_0_0
  id: ccsds_rs_decode_rs_test
  parameters:
    affinity: '4'
    dual_basis: '1'
    interleave: '1'
  states: {}
- name: ccsds_rs_decode_rs_test_0_0_0
  id: ccsds_rs_decode_rs_test
  parameters:
    affinity: '6'
    dual_basis: '1'
    interleave: '1'
  states: {}
- name: ccsds_rs_decode_rs_test_0_0_0_0
  id: ccsds_rs_decode_rs_test
  parameters:
    affinity: '7'
    dual_basis: '1'
    interleave: '1'
  states: {}
- name: ccsds_rs_decode_rs_test_0_0_1
  id: ccsds_rs_decode_rs_test
  parameters:
    affinity: '5'
    dual_basis: '1'
    interleave: '1'
  states: {}
- name: fec_extended_decoder_0
  id: fec_extended_decoder
  parameters:
    affinity: '3'
    decoder_list: variable_cc_decoder_def_0
    puncpat: '''11'''
    threadtype: capillary
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    affinity: '0'
    name: My Decode Block Output
    size: '128'
    srate: samp_rate
    type: float
    update_time: '1.0'
    ymax: '2'
  states: {}
- name: zeromq_pull_source_0
  id: zeromq_pull_source
  parameters:
    address: tcp://127.0.0.1:5555
    affinity: '0'
    timeout: '100'
    type: byte
  states: {}
- name: zeromq_push_sink_0
  id: zeromq_push_sink
  parameters:
    address: tcp://127.0.0.1:5555
    affinity: '0'
    timeout: '100'
    type: byte
  states: {}

connections:
- [HighDataRate_Modem_Frame_Extract_0, '0', HighDataRate_Modem_Resolve_Phase_0, '0']
- [HighDataRate_Modem_Resolve_Phase_0, '0', blocks_stream_demux_0_0, '0']
- [HighDataRate_Modem_Tag_FrameASM_0, '0', HighDataRate_Modem_Frame_Extract_0, '0']
- [blocks_add_const_vxx_0, '0', fec_extended_decoder_0, '0']
- [blocks_char_to_float_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_char_to_float_0_0_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [blocks_file_source_0_0_0_0_0_0, '0', blocks_unpack_k_bits_bb_0_0_0_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_pack_k_bits_bb_0_0, '0', blocks_stream_demux_0, '0']
- [blocks_stream_demux_0, '0', blocks_stream_to_vector_2_0_0_0, '0']
- [blocks_stream_demux_0, '1', blocks_stream_to_vector_2_0_0_1, '0']
- [blocks_stream_demux_0, '2', blocks_stream_to_vector_2_0_0_2, '0']
- [blocks_stream_demux_0, '3', blocks_stream_to_vector_2_0_0_2_0, '0']
- [blocks_stream_demux_0_0, '0', blocks_null_sink_1, '0']
- [blocks_stream_demux_0_0, '1', blocks_pack_k_bits_bb_0_0, '0']
- [blocks_stream_mux_0, '0', blocks_char_to_float_0_0_0, '0']
- [blocks_stream_mux_0, '0', zeromq_push_sink_0, '0']
- [blocks_stream_to_vector_2_0_0_0, '0', ccsds_rs_decode_rs_test_0_0, '0']
- [blocks_stream_to_vector_2_0_0_1, '0', ccsds_rs_decode_rs_test_0_0_1, '0']
- [blocks_stream_to_vector_2_0_0_2, '0', ccsds_rs_decode_rs_test_0_0_0, '0']
- [blocks_stream_to_vector_2_0_0_2_0, '0', ccsds_rs_decode_rs_test_0_0_0_0, '0']
- [blocks_tag_gate_0, '0', HighDataRate_Modem_Tag_FrameASM_0, '0']
- [blocks_throttle_0_0_0, '0', blocks_char_to_float_0, '0']
- [blocks_unpack_k_bits_bb_0_0_0_0_0, '0', blocks_throttle_0_0_0, '0']
- [blocks_vector_to_stream_0_1_0_0, '0', blocks_stream_mux_0, '0']
- [blocks_vector_to_stream_0_1_0_1, '0', blocks_stream_mux_0, '1']
- [blocks_vector_to_stream_0_1_0_2, '0', blocks_stream_mux_0, '2']
- [blocks_vector_to_stream_0_1_0_2_0, '0', blocks_stream_mux_0, '3']
- [ccsds_rs_decode_rs_test_0_0, '0', blocks_vector_to_stream_0_1_0_0, '0']
- [ccsds_rs_decode_rs_test_0_0_0, '0', blocks_vector_to_stream_0_1_0_2, '0']
- [ccsds_rs_decode_rs_test_0_0_0_0, '0', blocks_vector_to_stream_0_1_0_2_0, '0']
- [ccsds_rs_decode_rs_test_0_0_1, '0', blocks_vector_to_stream_0_1_0_1, '0']
- [fec_extended_decoder_0, '0', blocks_tag_gate_0, '0']
- [zeromq_pull_source_0, '0', blocks_file_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.0
