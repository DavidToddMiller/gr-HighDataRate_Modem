options:
  parameters:
    description: DVB-S2 Physical Layer (PL) Synchronization
    generate_options: qt_gui
    id: dvbs2_pl_sync
    output_language: python
    title: DVB-S2 PL Sync
  states: {}

blocks:
- name: Es
  id: variable
  parameters:
    value: '1'
  states: {}
- name: EsN0
  id: variable
  parameters:
    value: 10 ** (snr / 10)
  states: {}
- name: N0
  id: variable
  parameters:
    value: Es / EsN0
  states: {}
- name: code_rate
  id: variable
  parameters:
    value: modcod.upper().replace("8PSK", "").replace("QPSK", "")
  states: {}
- name: constellation
  id: variable
  parameters:
    value: modcod.replace(code_rate, "")
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    label: Frequency Offset (Hz)
    start: '-sym_rate/4'
    step: 1e3
    stop: sym_rate/4
    value: '10000'
  states: {}
- name: n_rrc_taps
  id: variable
  parameters:
    value: int(2*rrc_delay*sps) + 1
  states: {}
- name: pilot_len
  id: variable
  parameters:
    value: int((360-1)/16)*36
  states: {}
- name: plframe_len
  id: variable
  parameters:
    value: '33282'
  states: {}
- name: plheader_len
  id: variable
  parameters:
    value: '90'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: sps*sym_rate
  states: {}
- name: snr
  id: variable_qtgui_range
  parameters:
    label: SNR (dB)
    start: '0'
    step: '0.1'
    stop: '20'
    value: '10'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '2'
  states: {}
- name: sym_rate
  id: variable
  parameters:
    value: 1e6*6
  states: {}
- name: agc_gain
  id: parameter
  parameters:
    label: AGC gain
    type: eng_float
    value: '1'
  states: {}
- name: agc_rate
  id: parameter
  parameters:
    label: AGC update rate
    type: eng_float
    value: '1e-5'
  states: {}
- name: agc_ref
  id: parameter
  parameters:
    label: AGC's reference value
    type: eng_float
    value: '1'
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    affinity: '0'
    file: /home/davem/gr-HighDataRate_Modem/examples/High_Speed_FEP-Gateway_CCSDS_DVBS2_LDPC_BCH_ZeroMQ/HighSpeed_FEP_Gateway_SINK
    type: byte
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    affinity: '1'
    file: /home/davem/gr-HighDataRate_Modem/examples/High_Speed_FEP-Gateway_CCSDS_DVBS2_LDPC_BCH_ZeroMQ/DVB_QPSK_test1
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_pack_k_bits_bb_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    affinity: '7'
    k: '8'
  states: {}
- name: blocks_stream_demux_0
  id: blocks_stream_demux
  parameters:
    affinity: '1'
    lengths: (32400,32400,32400,32400)
    num_outputs: '4'
    type: complex
  states: {}
- name: blocks_stream_mux_0
  id: blocks_stream_mux
  parameters:
    affinity: '6'
    lengths: (32208, 32208, 32208, 32208)
    num_inputs: '4'
    type: byte
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    affinity: '6'
    samples_per_second: '9941000'
    type: byte
  states: {}
- name: debug
  id: parameter
  parameters:
    label: Debug Level
    short_id: d
    type: intx
    value: '0'
  states: {}
- name: dvbs2rx_bch_decoder_bb_0_0
  id: dvbs2rx_bch_decoder_bb
  parameters:
    affinity: '2'
    framesize: frame_size
    outputmode: OM_MESSAGE
    rate: code_rate
    standard: DVB-S2
  states: {}
- name: dvbs2rx_bch_decoder_bb_0_0_0
  id: dvbs2rx_bch_decoder_bb
  parameters:
    affinity: '3'
    framesize: frame_size
    outputmode: OM_MESSAGE
    rate: code_rate
    standard: DVB-S2
  states: {}
- name: dvbs2rx_bch_decoder_bb_0_0_0_0
  id: dvbs2rx_bch_decoder_bb
  parameters:
    affinity: '4'
    framesize: frame_size
    outputmode: OM_MESSAGE
    rate: code_rate
    standard: DVB-S2
  states: {}
- name: dvbs2rx_bch_decoder_bb_0_0_0_0_0
  id: dvbs2rx_bch_decoder_bb
  parameters:
    affinity: '5'
    framesize: frame_size
    outputmode: OM_MESSAGE
    rate: code_rate
    standard: DVB-S2
  states: {}
- name: dvbs2rx_ldpc_decoder_cb_0_0
  id: dvbs2rx_ldpc_decoder_cb
  parameters:
    affinity: '2'
    constellation: constellation
    framesize: frame_size
    infomode: INFO_OFF
    max_trials: '25'
    outputmode: OM_MESSAGE
    rate: code_rate
    standard: DVB-S2
  states: {}
- name: dvbs2rx_ldpc_decoder_cb_0_1
  id: dvbs2rx_ldpc_decoder_cb
  parameters:
    affinity: '5'
    constellation: constellation
    framesize: frame_size
    infomode: INFO_OFF
    max_trials: '25'
    outputmode: OM_MESSAGE
    rate: code_rate
    standard: DVB-S2
  states: {}
- name: dvbs2rx_ldpc_decoder_cb_0_2
  id: dvbs2rx_ldpc_decoder_cb
  parameters:
    affinity: '4'
    constellation: constellation
    framesize: frame_size
    infomode: INFO_OFF
    max_trials: '25'
    outputmode: OM_MESSAGE
    rate: code_rate
    standard: DVB-S2
  states: {}
- name: dvbs2rx_ldpc_decoder_cb_0_3
  id: dvbs2rx_ldpc_decoder_cb
  parameters:
    affinity: '3'
    constellation: constellation
    framesize: frame_size
    infomode: INFO_OFF
    max_trials: '25'
    outputmode: OM_MESSAGE
    rate: code_rate
    standard: DVB-S2
  states: {}
- name: frame_size
  id: parameter
  parameters:
    label: FECFRAME size
    short_id: f
    type: str
    value: normal
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import pi, sqrt
  states: {}
- name: in_file
  id: parameter
  parameters:
    label: path to input file containing an MPEG TS stream
    type: str
    value: ../data/example.ts
  states: {}
- name: modcod
  id: parameter
  parameters:
    label: MODCOD
    short_id: m
    type: str
    value: QPSK1/2
  states: {}
- name: rolloff
  id: parameter
  parameters:
    label: rolloff factor
    short_id: r
    type: eng_float
    value: '0.2'
  states: {}
- name: rrc_delay
  id: parameter
  parameters:
    label: RRC filter delay in symbol periods
    type: intx
    value: '25'
  states: {}
- name: rrc_nfilts
  id: parameter
  parameters:
    label: number of branches on the polyphase RRC filter
    type: intx
    value: '128'
  states: {}
- name: sym_sync_damping
  id: parameter
  parameters:
    label: symbol synchronizer's damping factor
    type: eng_float
    value: '1.0'
  states: {}
- name: sym_sync_loop_bw
  id: parameter
  parameters:
    label: symbol synchronizer's loop bandwidth
    type: eng_float
    value: '0.0045'
  states: {}
- name: zeromq_pull_source_0
  id: zeromq_pull_source
  parameters:
    address: tcp://127.0.0.1:5555
    affinity: '0'
    timeout: '100'
    type: byte
  states: {}
- name: zeromq_push_sink_0
  id: zeromq_push_sink
  parameters:
    address: tcp://127.0.0.1:5555
    affinity: '7'
    timeout: '100'
    type: byte
  states: {}

connections:
- [blocks_file_source_0_0, '0', blocks_stream_demux_0, '0']
- [blocks_pack_k_bits_bb_0_0, '0', zeromq_push_sink_0, '0']
- [blocks_stream_demux_0, '0', dvbs2rx_ldpc_decoder_cb_0_0, '0']
- [blocks_stream_demux_0, '1', dvbs2rx_ldpc_decoder_cb_0_3, '0']
- [blocks_stream_demux_0, '2', dvbs2rx_ldpc_decoder_cb_0_2, '0']
- [blocks_stream_demux_0, '3', dvbs2rx_ldpc_decoder_cb_0_1, '0']
- [blocks_stream_mux_0, '0', blocks_throttle_0_0, '0']
- [blocks_throttle_0_0, '0', blocks_pack_k_bits_bb_0_0, '0']
- [dvbs2rx_bch_decoder_bb_0_0, '0', blocks_stream_mux_0, '0']
- [dvbs2rx_bch_decoder_bb_0_0_0, '0', blocks_stream_mux_0, '1']
- [dvbs2rx_bch_decoder_bb_0_0_0_0, '0', blocks_stream_mux_0, '2']
- [dvbs2rx_bch_decoder_bb_0_0_0_0_0, '0', blocks_stream_mux_0, '3']
- [dvbs2rx_ldpc_decoder_cb_0_0, '0', dvbs2rx_bch_decoder_bb_0_0, '0']
- [dvbs2rx_ldpc_decoder_cb_0_1, '0', dvbs2rx_bch_decoder_bb_0_0_0_0_0, '0']
- [dvbs2rx_ldpc_decoder_cb_0_2, '0', dvbs2rx_bch_decoder_bb_0_0_0_0, '0']
- [dvbs2rx_ldpc_decoder_cb_0_3, '0', dvbs2rx_bch_decoder_bb_0_0_0, '0']
- [zeromq_pull_source_0, '0', blocks_file_sink_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.0
